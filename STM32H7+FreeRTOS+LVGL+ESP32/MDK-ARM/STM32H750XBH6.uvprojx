# Keil uVision project STM32H750XBH6.uvprojx, settings and files
target STM32H750XBH6 (6230000::V6.23::ARMCLANG)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32H750XBH6 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H750xx,ARM_MATH_CM7,USE_PWR_LDO_SUPPLY,LV_CONF_INCLUDE_SIMPLE
  c misc: -Wno-invalid-source-encoding
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Drivers/User/Inc;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;./HARDWORK;./HARDWORK/CMSIS-DSP;./HARDWORK/CMSIS-DSP/1.16.2;./HARDWORK/CMSIS-DSP/1.16.2/Source;./HARDWORK/CMSIS-DSP/1.16.2/Source/BasicMathFunctions;./HARDWORK/CMSIS-DSP/1.16.2/Source/BayesFunctions;./HARDWORK/CMSIS-DSP/1.16.2/Source/CommonTables;./HARDWORK/CMSIS-DSP/1.16.2/Source/ComplexMathFunctions;./HARDWORK/CMSIS-DSP/1.16.2/Source/ControllerFunctions;./HARDWORK/CMSIS-DSP/1.16.2/Source/DistanceFunctions;./HARDWORK/CMSIS-DSP/1.16.2/Source/FastMathFunctions;./HARDWORK/CMSIS-DSP/1.16.2/Source/FilteringFunctions;./HARDWORK/CMSIS-DSP/1.16.2/Source/InterpolationFunctions;./HARDWORK/CMSIS-DSP/1.16.2/Source/MatrixFunctions;./HARDWORK/CMSIS-DSP/1.16.2/Source/QuaternionMathFunctions;./HARDWORK/CMSIS-DSP/1.16.2/Source/StatisticsFunctions;./HARDWORK/CMSIS-DSP/1.16.2/Source/SupportFunctions;./HARDWORK/CMSIS-DSP/1.16.2/Source/SVMFunctions;./HARDWORK/CMSIS-DSP/1.16.2/Source/TransformFunctions;./HARDWORK/CMSIS-DSP/1.16.2/Source/WindowFunctions;./HARDWORK/CMSIS-DSP/1.16.2/PrivateInclude;./HARDWORK/CMSIS-DSP/1.16.2/Include;./HARDWORK/DELAY;./HARDWORK/CHANGEGUI;./HARDWORK/GUI-Guider_Runtime/src/generated;./HARDWORK/GUI-Guider_Runtime/src/custom;./HARDWORK/AD7606;../FATFS/Target;../FATFS/App;../Middlewares/Third_Party/FatFs/src;./HARDWORK/SD_Card;../lvgl-9.4.0;../lvgl-9.4.0/src;../lvgl-9.4.0/src/core;../lvgl-9.4.0/src/display;../lvgl-9.4.0/src/draw;../lvgl-9.4.0/src/draw/convert;../lvgl-9.4.0/src/draw/convert/helium;../lvgl-9.4.0/src/draw/convert/neon;../lvgl-9.4.0/src/draw/dma2d;../lvgl-9.4.0/src/draw/sw;../lvgl-9.4.0/src/draw/sw/arm2d;../lvgl-9.4.0/src/draw/sw/blend;../lvgl-9.4.0/src/draw/sw/blend/arm2d;../lvgl-9.4.0/src/draw/sw/blend/helium;../lvgl-9.4.0/src/draw/sw/blend/neon;../lvgl-9.4.0/src/font;../lvgl-9.4.0/src/indev;../lvgl-9.4.0/src/layouts;../lvgl-9.4.0/src/layouts/flex;../lvgl-9.4.0/src/layouts/grid;../lvgl-9.4.0/src/misc;../lvgl-9.4.0/src/misc/cache;../lvgl-9.4.0/src/misc/cache/class;../lvgl-9.4.0/src/misc/cache/instance;../lvgl-9.4.0/src/osal;../lvgl-9.4.0/src/others;../lvgl-9.4.0/src/others/file_explorer;../lvgl-9.4.0/src/others/font_manager;../lvgl-9.4.0/src/others/fragment;../lvgl-9.4.0/src/others/gridnav;../lvgl-9.4.0/src/others/ime;../lvgl-9.4.0/src/others/imgfont;../lvgl-9.4.0/src/others/monkey;../lvgl-9.4.0/src/others/observer;../lvgl-9.4.0/src/others/snapshot;../lvgl-9.4.0/src/others/sysmon;../lvgl-9.4.0/src/others/test;../lvgl-9.4.0/src/others/translation;../lvgl-9.4.0/src/others/vg_lite_tvg;../lvgl-9.4.0/src/others/xml;../lvgl-9.4.0/src/others/xml/parsers;../lvgl-9.4.0/src/stdlib;../lvgl-9.4.0/src/stdlib/builtin;../lvgl-9.4.0/src/stdlib/clib;../lvgl-9.4.0/src/stdlib/micropython;../lvgl-9.4.0/src/stdlib/rtthread;../lvgl-9.4.0/src/stdlib/uefi;../lvgl-9.4.0/src/themes;../lvgl-9.4.0/src/themes/default;../lvgl-9.4.0/src/themes/mono;../lvgl-9.4.0/src/themes/simple;../lvgl-9.4.0/src/tick;../lvgl-9.4.0/src/widgets;../lvgl-9.4.0/src/widgets/3dtexture;../lvgl-9.4.0/src/widgets/animimage;../lvgl-9.4.0/src/widgets/arc;../lvgl-9.4.0/src/widgets/arclabel;../lvgl-9.4.0/src/widgets/bar;../lvgl-9.4.0/src/widgets/buttonmatrix;../lvgl-9.4.0/src/widgets/calendar;../lvgl-9.4.0/src/widgets/canvas;../lvgl-9.4.0/src/widgets/chart;../lvgl-9.4.0/src/widgets/checkbox;../lvgl-9.4.0/src/widgets/dropdown;../lvgl-9.4.0/src/widgets/image;../lvgl-9.4.0/src/widgets/imagebutton;../lvgl-9.4.0/src/widgets/keyboard;../lvgl-9.4.0/src/widgets/label;../lvgl-9.4.0/src/widgets/led;../lvgl-9.4.0/src/widgets/line;../lvgl-9.4.0/src/widgets/list;../lvgl-9.4.0/src/widgets/lottie;../lvgl-9.4.0/src/widgets/menu;../lvgl-9.4.0/src/widgets/msgbox;../lvgl-9.4.0/src/widgets/objx_templ;../lvgl-9.4.0/src/widgets/property;../lvgl-9.4.0/src/widgets/roller;../lvgl-9.4.0/src/widgets/scale;../lvgl-9.4.0/src/widgets/slider;../lvgl-9.4.0/src/widgets/span;../lvgl-9.4.0/src/widgets/spinbox;../lvgl-9.4.0/src/widgets/spinner;../lvgl-9.4.0/src/widgets/switch;../lvgl-9.4.0/src/widgets/table;../lvgl-9.4.0/src/widgets/tabview;../lvgl-9.4.0/src/widgets/textarea;../lvgl-9.4.0/src/widgets/tileview;../lvgl-9.4.0/src/widgets/win;../lvgl-9.4.0/examples;../lvgl-9.4.0/examples/porting;../lvgl-9.4.0/lvgl;../lvgl-9.4.0/demos;../lvgl-9.4.0/demos/widgets;../lvgl-9.4.0/demos/widgets/assets;../lvgl-9.4.0/demos/benchmark;../lvgl-9.4.0/demos/benchmark/assets;./HARDWORK/EdgeComm;./HARDWORK/W25Q256;./HARDWORK/EdgeWind_UI;./HARDWORK/EdgeWind_UI/screens;./HARDWORK/EdgeWind_UI/components;./HARDWORK/EdgeWind_UI/fonts;./HARDWORK/EdgeWind_UI/images
  asm include: ../Core/Inc;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s
    ../FATFS/Target/: qspi_diskio.c qspi_diskio.h
  group Application/User/Core
    ../Core/Src/: ad_acq_buffers.c main.c gpio.c freertos.c dma.c dma2d.c fmc.c ltdc.c mdma.c quadspi.c rtc.c sdmmc.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/User
    ../Drivers/User/Src/: led.c sdram.c lcd_fonts.c lcd_image.c lcd_rgb.c touch_iic.c touch_800x480.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dma2d.c stm32h7xx_ll_fmc.c stm32h7xx_hal_nor.c stm32h7xx_hal_sram.c stm32h7xx_hal_nand.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_dsi.c stm32h7xx_hal_qspi.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group CMSIS_DSP1.16.2
    ./HARDWORK/CMSIS-DSP/1.16.2/Source/BasicMathFunctions/: BasicMathFunctions.c
    ./HARDWORK/CMSIS-DSP/1.16.2/Source/BayesFunctions/: BayesFunctions.c
    ./HARDWORK/CMSIS-DSP/1.16.2/Source/CommonTables/: CommonTables.c
    ./HARDWORK/CMSIS-DSP/1.16.2/Source/ComplexMathFunctions/: ComplexMathFunctions.c
    ./HARDWORK/CMSIS-DSP/1.16.2/Source/ControllerFunctions/: ControllerFunctions.c
    ./HARDWORK/CMSIS-DSP/1.16.2/Source/DistanceFunctions/: DistanceFunctions.c
    ./HARDWORK/CMSIS-DSP/1.16.2/Source/FastMathFunctions/: FastMathFunctions.c
    ./HARDWORK/CMSIS-DSP/1.16.2/Source/FilteringFunctions/: FilteringFunctions.c
    ./HARDWORK/CMSIS-DSP/1.16.2/Source/InterpolationFunctions/: InterpolationFunctions.c
    ./HARDWORK/CMSIS-DSP/1.16.2/Source/MatrixFunctions/: MatrixFunctions.c
    ./HARDWORK/CMSIS-DSP/1.16.2/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
    ./HARDWORK/CMSIS-DSP/1.16.2/Source/StatisticsFunctions/: StatisticsFunctions.c
    ./HARDWORK/CMSIS-DSP/1.16.2/Source/SupportFunctions/: SupportFunctions.c
    ./HARDWORK/CMSIS-DSP/1.16.2/Source/SVMFunctions/: SVMFunctions.c
    ./HARDWORK/CMSIS-DSP/1.16.2/Source/TransformFunctions/: TransformFunctions.c
    ./HARDWORK/CMSIS-DSP/1.16.2/Source/WindowFunctions/: WindowFunctions.c
  group DELAY
    ./HARDWORK/DELAY/: delay.c delay.h
  group AD7606
    ./HARDWORK/AD7606/: SPI_AD7606 .c SPI_AD7606.h
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
  group SD_Card
    ./HARDWORK/SD_Card/: SD.c SD.h sd_time.c sd_time.h sd_config.c sd_config.h sd_waveform.c sd_waveform.h sd_fault_log.c sd_fault_log.h sd_diskio_user.c sd_diskio_user.h
  group LVGL_Core
    ../lvgl-9.4.0/src/: lv_init.c
    ../lvgl-9.4.0/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
    ../lvgl-9.4.0/src/display/: lv_display.c
    ../lvgl-9.4.0/src/indev/: lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ../lvgl-9.4.0/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../lvgl-9.4.0/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../lvgl-9.4.0/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../lvgl-9.4.0/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../lvgl-9.4.0/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
    ../lvgl-9.4.0/src/tick/: lv_tick.c
    ../lvgl-9.4.0/src/stdlib/: lv_mem.c
    ../lvgl-9.4.0/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../lvgl-9.4.0/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
  group LVGL_Draw
    ../lvgl-9.4.0/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../lvgl-9.4.0/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c
    ../lvgl-9.4.0/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../lvgl-9.4.0/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../lvgl-9.4.0/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
    ../lvgl-9.4.0/src/draw/convert/helium/: lv_draw_buf_convert_helium.c
    ../lvgl-9.4.0/src/draw/convert/neon/: lv_draw_buf_convert_neon.c
    ../lvgl-9.4.0/src/draw/convert/: lv_draw_buf_convert.c
  group LVGL_Widgets
    ../lvgl-9.4.0/src/widgets/3dtexture/: lv_3dtexture.c
    ../lvgl-9.4.0/src/widgets/animimage/: lv_animimage.c
    ../lvgl-9.4.0/src/widgets/arc/: lv_arc.c
    ../lvgl-9.4.0/src/widgets/arclabel/: lv_arclabel.c
    ../lvgl-9.4.0/src/widgets/bar/: lv_bar.c
    ../lvgl-9.4.0/src/widgets/button/: lv_button.c
    ../lvgl-9.4.0/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../lvgl-9.4.0/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../lvgl-9.4.0/src/widgets/canvas/: lv_canvas.c
    ../lvgl-9.4.0/src/widgets/chart/: lv_chart.c
    ../lvgl-9.4.0/src/widgets/checkbox/: lv_checkbox.c
    ../lvgl-9.4.0/src/widgets/dropdown/: lv_dropdown.c
    ../lvgl-9.4.0/src/widgets/image/: lv_image.c
    ../lvgl-9.4.0/src/widgets/imagebutton/: lv_imagebutton.c
    ../lvgl-9.4.0/src/widgets/keyboard/: lv_keyboard.c
    ../lvgl-9.4.0/src/widgets/label/: lv_label.c
    ../lvgl-9.4.0/src/widgets/led/: lv_led.c
    ../lvgl-9.4.0/src/widgets/line/: lv_line.c
    ../lvgl-9.4.0/src/widgets/list/: lv_list.c
    ../lvgl-9.4.0/src/widgets/lottie/: lv_lottie.c
    ../lvgl-9.4.0/src/widgets/menu/: lv_menu.c
    ../lvgl-9.4.0/src/widgets/msgbox/: lv_msgbox.c
    ../lvgl-9.4.0/src/widgets/objx_templ/: lv_objx_templ.c
    ../lvgl-9.4.0/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_textarea_properties.c
    ../lvgl-9.4.0/src/widgets/roller/: lv_roller.c
    ../lvgl-9.4.0/src/widgets/scale/: lv_scale.c
    ../lvgl-9.4.0/src/widgets/slider/: lv_slider.c
    ../lvgl-9.4.0/src/widgets/span/: lv_span.c
    ../lvgl-9.4.0/src/widgets/spinbox/: lv_spinbox.c
    ../lvgl-9.4.0/src/widgets/spinner/: lv_spinner.c
    ../lvgl-9.4.0/src/widgets/switch/: lv_switch.c
    ../lvgl-9.4.0/src/widgets/table/: lv_table.c
    ../lvgl-9.4.0/src/widgets/tabview/: lv_tabview.c
    ../lvgl-9.4.0/src/widgets/textarea/: lv_textarea.c
    ../lvgl-9.4.0/src/widgets/tileview/: lv_tileview.c
    ../lvgl-9.4.0/src/widgets/win/: lv_win.c
  group LVGL_Extra
    ../lvgl-9.4.0/src/layouts/flex/: lv_flex.c
    ../lvgl-9.4.0/src/layouts/grid/: lv_grid.c
    ../lvgl-9.4.0/src/layouts/: lv_layout.c
    ../lvgl-9.4.0/src/themes/default/: lv_theme_default.c
    ../lvgl-9.4.0/src/themes/mono/: lv_theme_mono.c
    ../lvgl-9.4.0/src/themes/simple/: lv_theme_simple.c
    ../lvgl-9.4.0/src/themes/: lv_theme.c
    ../lvgl-9.4.0/src/libs/bin_decoder/: lv_bin_decoder.c
    ../lvgl-9.4.0/src/libs/fsdrv/: lv_fs_fatfs.c lv_fs_memfs.c
    ../lvgl-9.4.0/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../lvgl-9.4.0/src/others/file_explorer/: lv_file_explorer.c
    ../lvgl-9.4.0/src/others/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../lvgl-9.4.0/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../lvgl-9.4.0/src/others/gridnav/: lv_gridnav.c
    ../lvgl-9.4.0/src/others/ime/: lv_ime_pinyin.c
    ../lvgl-9.4.0/src/others/imgfont/: lv_imgfont.c
    ../lvgl-9.4.0/src/others/monkey/: lv_monkey.c
    ../lvgl-9.4.0/src/others/observer/: lv_observer.c
    ../lvgl-9.4.0/src/others/snapshot/: lv_snapshot.c
    ../lvgl-9.4.0/src/others/sysmon/: lv_sysmon.c
    ../lvgl-9.4.0/src/others/test/: lv_test_display.c lv_test_helpers.c lv_test_indev.c lv_test_indev_gesture.c lv_test_screenshot_compare.c
    ../lvgl-9.4.0/src/others/translation/: lv_translation.c
    ../lvgl-9.4.0/src/others/vg_lite_tvg/: vg_lite_matrix.c
    ../lvgl-9.4.0/src/others/xml/: lv_xml.c lv_xml_base_types.c lv_xml_component.c lv_xml_load.c lv_xml_parser.c lv_xml_style.c lv_xml_test.c lv_xml_translation.c lv_xml_update.c lv_xml_utils.c lv_xml_widget.c
    ../lvgl-9.4.0/src/others/xml/parsers/: lv_xml_arc_parser.c lv_xml_bar_parser.c lv_xml_button_parser.c lv_xml_buttonmatrix_parser.c lv_xml_calendar_parser.c lv_xml_canvas_parser.c lv_xml_chart_parser.c lv_xml_checkbox_parser.c lv_xml_dropdown_parser.c lv_xml_image_parser.c lv_xml_keyboard_parser.c lv_xml_label_parser.c lv_xml_obj_parser.c lv_xml_qrcode_parser.c lv_xml_roller_parser.c lv_xml_scale_parser.c lv_xml_slider_parser.c lv_xml_spangroup_parser.c lv_xml_spinbox_parser.c lv_xml_switch_parser.c lv_xml_table_parser.c lv_xml_tabview_parser.c lv_xml_textarea_parser.c
  group LVGL_Porting
    ../lvgl-9.4.0/: lv_version.h lvgl.h lvgl_private.h lv_conf.h
    ../lvgl-9.4.0/examples/porting/: lv_port_disp.c lv_port_disp.h lv_port_indev.c lv_port_indev.h
  group LVGL_Demo
    ../lvgl-9.4.0/demos/: lv_demos.c
    ../lvgl-9.4.0/demos/widgets/: lv_demo_widgets.c lv_demo_widgets_analytics.c lv_demo_widgets_components.c lv_demo_widgets_profile.c lv_demo_widgets_shop.c
    ../lvgl-9.4.0/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_demo_widgets_needle.c img_lvgl_logo.c
  group EdgeComm
    ./HARDWORK/EdgeComm/: edge_comm.c edge_comm.h edge_comm_config.h
  group ESP32SPI
    ./HARDWORK/ESP32SPI/: esp32_spi_debug.c esp32_spi_debug.h
  group W25Q256
    ./HARDWORK/W25Q256/: qspi_w25q256.c qspi_w25q256.h
  group EdgeWind_UI
    ./HARDWORK/EdgeWind_UI/: edgewind_ui.c
    ./HARDWORK/EdgeWind_UI/screens/: scr_boot_anim.c
    ./HARDWORK/EdgeWind_UI/fonts/: lv_font_SourceHanSerifSC_Regular_14.c
  group GUI_Guider_Runtime
    ./HARDWORK/GUI-Guider_Runtime/: guider_entry.c gui_assets.c gui_ime_pinyin.c gui_assets.h gui_ime_pinyin.h gui_assets_sync.c gui_assets_sync.h
    ./HARDWORK/GUI-Guider_Runtime/src/custom/: custom.c scr_aurora.c scr_aurora.h
    ./HARDWORK/GUI-Guider_Runtime/src/generated/: events_init.c gui_guider.c widgets_init.c setup_scr_Main_1.c setup_scr_RealtimeMonitor.c setup_scr_Main_2.c setup_scr_Main_3.c setup_scr_WifiConfig.c setup_scr_ServerConfig.c setup_scr_ParamConfig.c setup_scr_DeviceConnect.c
software components: CMSIS:CORE 5.5.0
